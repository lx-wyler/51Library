# Keil uVision project 51spi.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: 51spi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\uart;.\epaper;.\led;.\other_head;.\keyboard;.\smg;.\OLED;.\mycommon
  group Source Group 1
    ./: STARTUP.A51 main.c
  group uart
    ./uart/: uart.c uart.h
  group epaper
    ./epaper/: ePaper.c ePaper.h
  group led
    ./led/: LED.c LED.h
  group other_head
    ./other_head/: PinDefine.h
  group smg
    ./smg/: smg.c smg.h
  group mycommon
    ./mycommon/: mycommon.c mycommon.h commonfront.h
  group OLED
    ./OLED/: oled.c oled.h
